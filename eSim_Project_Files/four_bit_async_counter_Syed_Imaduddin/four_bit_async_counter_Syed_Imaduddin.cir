* D:\Imad_Work_Folder\VLSI\Competitions\Mixed_Signal_Competition(24.Sept.2022)\GitHub_Repo\Asynchronous-Counter-4_Bit\eSim_Project_Files\four_bit_async_counter_Syed_Imaduddin\four_bit_async_counter_Syed_Imaduddin.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/8/2022 11:06:10 AM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
v1  in GND DC
U3  in plot_v1
v2  rst GND pulse
U7  Q0 plot_v1
U8  Q1 plot_v1
U10  Q2 plot_v1
U11  Q3 plot_v1
U12  clk rst t Net-_U12-Pad4_ Net-_U12-Pad5_ Net-_U12-Pad6_ adc_bridge_3
U13  Net-_U13-Pad1_ Net-_U13-Pad2_ Net-_U13-Pad3_ Net-_U13-Pad4_ Q0 Q1 Q2 Q3 dac_bridge_4
U14  clk plot_v1
U1  rst plot_v1
U2  t plot_v1
scmode1  SKY130mode
SC8  GND Q3 in sky130_fd_pr__res_generic_pd
SC7  GND Q2 in sky130_fd_pr__res_generic_pd
SC6  GND Q1 in sky130_fd_pr__res_generic_pd
SC5  GND Q0 in sky130_fd_pr__res_generic_pd
SC2  Net-_SC1-Pad1_ clk GND GND sky130_fd_pr__nfet_01v8
SC1  Net-_SC1-Pad1_ clk in in sky130_fd_pr__pfet_01v8
SC9  Net-_SC10-Pad1_ Net-_SC1-Pad1_ GND GND sky130_fd_pr__nfet_01v8
SC4  Net-_SC10-Pad1_ Net-_SC1-Pad1_ in in sky130_fd_pr__pfet_01v8
SC12  clk Net-_SC10-Pad1_ GND GND sky130_fd_pr__nfet_01v8
SC11  clk Net-_SC10-Pad1_ in in sky130_fd_pr__pfet_01v8
SC3  Net-_SC1-Pad1_ GND sky130_fd_pr__cap_mim_m3_1
SC10  Net-_SC10-Pad1_ GND sky130_fd_pr__cap_mim_m3_1
SC13  clk GND sky130_fd_pr__cap_mim_m3_1
v3  t GND pulse
U4  Net-_U12-Pad4_ Net-_U12-Pad5_ Net-_U12-Pad6_ Net-_U13-Pad1_ imad_tff
U5  Net-_U13-Pad1_ Net-_U12-Pad5_ Net-_U12-Pad6_ Net-_U13-Pad2_ imad_tff
U6  Net-_U13-Pad2_ Net-_U12-Pad5_ Net-_U12-Pad6_ Net-_U13-Pad3_ imad_tff
U9  Net-_U13-Pad3_ Net-_U12-Pad5_ Net-_U12-Pad6_ Net-_U13-Pad4_ imad_tff

.end
